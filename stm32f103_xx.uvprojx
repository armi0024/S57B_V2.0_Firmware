# Keil uVision project stm32f103_xx.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103_xx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\user;.\core;.\stm32f1_lib\inc;.\system;.\hardware
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c system_stm32f10x.c mydef.h
  group core
    ./core/: core_cm3.c startup_stm32f10x_md.s
  group stm32f1_lib
    ./stm32f1_lib/src/: stm32f10x_adc.c stm32f10x_can.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c misc.c
  group sys
    ./system/: delay.c sys.c usart.c
  group hardware
    ./hardware/: gpio.c oled.c time.c key.c can.c display.c tle5012.c flash.c spi1.c exit.c iwdg.c
